options:
  parameters:
    generate_options: qt_gui
    id: iot
    output_language: python
    title: RollJam
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 43392e4
  states: {}
- name: jam
  id: variable
  parameters:
    value: 43370e4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 50e4
    low_cutoff_freq: 1e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\samue\Desktop\temp\signal.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Andrea\Downloads\signal2.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.009'
    init: '0'
    low: '0.009'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):

        def __init__(self, first_sink="signal.raw", second_sink="signal2.raw"):
          gr.sync_block.__init__(
            self,
            name='Embedded Python Block',
            in_sig=[np.complex64, np.complex64, np.float32],
            out_sig=[np.complex64]
          )
          self.first_signal = None
          self.second_signal = None
          self.first_sink = open(first_sink, 'w+b')
          self.second_sink = open(second_sink, 'w+b')
          self.first_signal_captured = False
          self.detected = False
          self.transmit = False
          self.finished = False
          self.timer = 0

        def work(self, input_items, output_items):
          input_jam = input_items[0] # Jamming signal
          input_sig = input_items[1] # Captured signal
          input_detect = input_items[2] # Signal detection

          if not self.finished:
            output_items[0][:] = 0 if self.first_signal_captured else input_jam
            if self.detected:
              if not self.first_signal_captured:
                self.first_signal = np.concatenate((self.first_signal, input_sig))
              else:
                self.second_signal = np.concatenate((self.second_signal, input_sig))
              if int(round(time.time() * 1000)) - self.timer >= 1000:
                print('Signal captured')
                if self.first_signal_captured:
                  self.second_sink.write(bytearray(self.second_signal))
                  self.first_sink.close()
                  self.second_sink.close()
                  self.finished = True
                else:
                    self.first_sink.write(bytearray(self.first_signal))
                    self.first_sink.close()
                self.detected = False
                self.first_signal_captured = True					
            elif 1 in input_detect:
              if not self.first_signal_captured:
                self.first_signal = input_sig
              else:
                self.second_signal = input_sig
                self.transmit = True
              self.timer = int(round(time.time() * 1000))
              self.detected = True

          # Trasmit the first signal
          elif len(self.first_signal) > 0:
            self.first_signal = self.send_signal(self.first_signal, output_items)

          # Trasmit the second signal
          elif len(self.second_signal) > 0:
            self.second_signal = self.send_signal(self.second_signal, output_items)
          
          return len(output_items[0])
        
        def send_signal(self, signal, output_items):
          if(len(signal) < len(output_items[0])):
            output_items[0][:len(signal)] = signal
            signal = []
          else:
            output_items[0][:] = signal[:len(output_items[0])]
            signal = signal[len(output_items[0]):]
          return signal
    first_sink: '''signal.raw'''
    second_sink: '''signal2.raw'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: jam
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: jam
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_sink_0_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: soapy_hackrf_sink_0_0_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1, '2']
- [blocks_throttle2_0, '0', soapy_hackrf_sink_0_0_0, '0']
- [blocks_throttle2_0_0, '0', soapy_hackrf_sink_0_0_0_0, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_1, '0', soapy_hackrf_sink_0_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', epy_block_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
